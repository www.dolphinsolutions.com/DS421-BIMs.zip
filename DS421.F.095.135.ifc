Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2023-03-31T16:25:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.11200.0000 - Exporter 18.0.0.412 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 31 16:25:35 2023 * Host: ANDYHOUSE * Database: C:\Users\ANDYHO~1.DOL\AppData\Local\Temp\{CF32C9E4-8A09-4867-B45F-88E343BF9AB5}\ifc * Database version: 5507 * Database creation date: Fri Mar 31 16:25:33 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 31 16:25:34 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 31 16:25:34 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: SoapDispenser, Family1:SoapDispenser:201861
In: Level 1
Type - PredefinedType: USERDEFINED; Material: Default
Type - Dimensions - Length: 95 mm; XY_Offset: 0 mm; YZ_Offset: 0 mm
Type - Identity Data - Description: AutomaticFoamSoapDispenserStraightSpoutCounterMounted; Manufacturer: DolphinSolutionsLimited; Model: DS421.F.095.135; OmniClass Number: 23.40.20.21.34; OmniClass Title: Soap Holders, Dispensers; Type Name: SoapDispenser; URL: www.dolphinsolutions.co.uk
Type - Model Properties - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_70_22_81:Soap dispensers; CodePerformance: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: FoamSoap_SMART; Finish: .1BrushedSatin_.2MirrorPolished_.3PVDBrushed_.4PVDPolished_.5PowderCoated_.6CeramicCoated; Grade: 316; IfcExportAs: IfcFurtnitureType; IfcExportType: SOAPDISPENSER; ManufacturerName: DolphinSolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DS421.F.095.135; ModelReference: Automatic_FoamSoap_StraightSpout_CounterMountedDispenser; Name: DS421.F.095.135; NBSDescription: SoapDispensers; NBSReference: 45-35-72/358; OmniclassCode: 22-01U+00A052U+00A019; OmniclassTitle: Sanitary Facilities; WarrantyDurationUnit: year
Type - Other - Category: Specialty Equipment; Family Name: Family1
Pset_BuildingElementProxyCommon - Reference: SoapDispenser
Pset_ManufacturerTypeInformation - ModelReference: Automatic_FoamSoap_StraightSpout_CounterMountedDispenser; Manufacturer: DolphinSolutionsLimited
Constraints - Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.0122521 m2; Volume: 0.000167606 m3
Other - Family: Family1: SoapDispenser; Family and Type: Family1: SoapDispenser; Type: Family1: SoapDispenser; Type Id: Family1: SoapDispenser
Phasing - Phase Created: New Construction
